# Autodesk Inventor assembly: Cam To Build Built
## iProperties
Created: 2006-07
Part Number: Cam To Build Built
Document SubType Name: Assembly
Designer: Maxime Debono
Author: Maxime Debono
