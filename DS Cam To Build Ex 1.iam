# Autodesk Inventor assembly: Cam Profiles
## iProperties
Created: 2006-07
Part Number: Cam Profiles
Document SubType Name: Assembly
Designer: Maxime Debono
Author: Maxime Debono
